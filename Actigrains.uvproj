# Keil uVision project Actigrains.uvproj, settings and files
target Target 1 (MCS-51)
  device: SH79F3283 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x7FFF) XRAM(0-0x4FF) CLOCK(12000000)
  output: Actigrains +hex
  c flags: Optimize=8 SizeSpeed=1
  group StartUp
    ./SRC/: STARTUP.A51
  group HAL
    ./SRC/: HD_cfg.c AD.c Buzzer.c LED.c Key.c SSP.c LCD.C IIC.c
  group Usr
    ./SRC/: Main.c System.c Script.c Time.c TempCtr.c
  group Utils
    ./SRC/: TableFunc.c Tables.c SinoLib.LIB math.asm
